# Keil uVision project Lab_01_Example_2_GPIO_PF0_PF4_Interrupt.uvprojx, settings and files
target TM4C123GH6PM (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example_7_1_GPIO_PortF_Interrupt
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: PF0_and_PF4_Input_Interrupt.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
